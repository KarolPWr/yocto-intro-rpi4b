# nasze overlaye w config.txt
RPI_EXTRA_CONFIG:append = "\ndtoverlay=kurs-led"
