FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://kurs.cfg"
