FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://prompt.cfg"
